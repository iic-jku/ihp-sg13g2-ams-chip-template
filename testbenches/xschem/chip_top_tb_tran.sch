** sch_path: testbenches/xschem/chip_top_tb_tran.sch
**.subckt chip_top_tb_tran
VDD VDD GND {VDD}
vclk clock GND pulse(0 {IOVDD} 0 100p 100p {0.5/fclk} {1/fclk})
vrst reset_n GND pulse({IOVDD} 0 {2/fclk} 100p 100p {2/fclk} 1 1)
R1 vout_RF_filt GND {Rload} m=1
C1 vout_RF GND {Cload} m=1
VIO VIO GND {IOVDD}
x1 ds_I_n ds_I_p lo_Ix lo_I i2c_sda lo_Q ds_Q_n ds_Q_p lo_Qx GND GND GND GND GND GND clock reset_n
+ GND spi_si spi_sclk vout_RF spi_sram_ce vout_RF vout_RF vout_RF i2c_scl GND uart_tx GND GND gpio_0
+ gpio_1 gpio_2 gpio_3 GND VIO VDD chip_top
**** begin user architecture code


*.include ../../verification/pex/chip_top_pex.spice
.include /foss/designs/Chip/ihp130/macros/counter/netlist/xspice/counter_top/counter_top.xspice
.param IOVDD=3.3
.param VDD=1.5
.param temp=27
.param Cload=10p
.param Rload=1k
.param fclk=56e6
.csparam fclk=fclk
.param fsig=124.600e3
.csparam fsig=fsig
.param flo=fclk/2
.csparam flo=flo
* .options klu reltol=1e-3 abstol=1e-12 gmin=1e-12 rshunt=1e12
.control

pre_osdi $PDK_ROOT/$PDK/libs.tech/ngspice/osdi/psp103.osdi
pre_osdi $PDK_ROOT/$PDK/libs.tech/ngspice/osdi/psp103_nqs.osdi
pre_osdi $PDK_ROOT/$PDK/libs.tech/ngspice/osdi/r3_cmc.osdi

set num_threads=32

* save all

* User Constants
* Increase tstop --> more FFT bins
* Decrease tstep --> higher fs/2 in FFT
let fmin = 0.1 * flo
let fmax = 5 * flo
let tstart = 1/fsig
let tstop = 2/fsig
let tstep = 0.1/flo

* Transient Operating Point Analysis
*optran 0 0 0 $&tstep $&tstart 0
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran $&tstep 1u 0
*tran $&tstep $&tstop $&tstart
write @schname\.raw

* Plotting
plot vout_RF vout_RF_filt

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata $DESIGNS/Chip/ihp130/scripts/plot_simulations/data/chip_top_tb_tran.txt v(clock) v(reset_n)
+ v(vout_RF) v(vout_RF_filt)

* FFT vout_RF_filt
setplot tran1
linearize vout_RF_filt
set specwindow=hanning
fft vout_RF_filt
setplot sp2

let N = length(vout_RF_filt)
let fres = frequency[n-1]/n
let fmin_idx = ceil(const.fmin/fres)
let fmax_idx = ceil(const.fmax/fres)
let vout_RF_filt_spec = mag(vout_RF_filt)
let vout_RF_filt_spec_slice = vout_RF_filt_spec[fmin_idx,fmax_idx]
let freq = frequency[fmin_idx,fmax_idx]
meas sp vout_RF_filt_max max vout_RF_filt_spec_slice
let vout_RF_filt_spec_db = 20*log10(vout_RF_filt_spec_slice/vout_RF_filt_max)
plot vout_RF_filt_spec_db vs freq

* Write Data
setscale freq
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata $DESIGNS/Chip/ihp130/scripts/plot_simulations/data/chip_top_tb_tran_fft_filt.txt
+ v(vout_RF_filt_spec_db)

* Calc HD2, HD3
* let sig_idx = ceil(const.f_sig/fres)
* let hd2_idx = 2*sig_idx
* let hd3_idx = 3*sig_idx
* let sig_pwr = iod_spec[sig_idx-1]^2+iod_spec[sig_idx]^2+iod_spec[sig_idx+1]^2
* let hd2_pwr = iod_spec[hd2_idx-1]^2+iod_spec[hd2_idx]^2+iod_spec[hd2_idx+1]^2
* let hd3_pwr = iod_spec[hd3_idx-1]^2+iod_spec[hd3_idx]^2+iod_spec[hd3_idx+1]^2
* let hd2 = sqrt(hd2_pwr/sig_pwr)
* let hd3 = sqrt(hd3_pwr/sig_pwr)
* let hd2_dB = 20*log10(hd2)
* let hd3_dB = 20*log10(hd3)
* print hd2_dB
* print hd3_dB

*quit
*rusage all
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt



.include $::PDK_ROOT/$::PDK/libs.ref/sg13g2_io/spice/sg13g2_io.spi


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
