** sch_path: macros/inverter/testbenches/xschem/inverter_top_tb_current.sch
**.subckt inverter_top_tb_current
VDD VDD GND {VDD}
vsine vin GND {Vcm}
C1 vout1 GND {Cload} m=1
C2 vout2 GND {Cload} m=1
C3 vout3 GND {Cload} m=1
C4 vout4 GND {Cload} m=1
x1 VDD vin vout4 GND vin vout3 vin vout2 vout1 vin inverter_top
**** begin user architecture code


* Current view of inverter_top (make current-view): the operating point at the
* worst case of the current limits, fast MOS at 1.65 V and 105 C, with every
* input at VDD/2, where each inverter draws its highest cross current
.param VDD=1.65
.csparam VDD=VDD
.param Vcm=VDD/2
.temp 105
.param Cload=10p
.param Rload=1k
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

save all
op
* current into the pins of the macro, VSS returns what VDD draws (the
* inputs and the capacitive loads carry no DC current)
let ivdd = -i(VDD)
let ivss = -ivdd
echo VDD $&ivdd > ../plot_simulations/data/inverter_top_tb_current.txt
echo VSS $&ivss >> ../plot_simulations/data/inverter_top_tb_current.txt
print ivdd

.endc



.lib cornerMOSlv.lib mos_ff
.lib cornerMOShv.lib mos_ff
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
