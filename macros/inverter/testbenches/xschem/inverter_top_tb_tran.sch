** sch_path: macros/inverter/testbenches/xschem/inverter_top_tb_tran.sch
**.subckt inverter_top_tb_tran
VDD VDD GND {VDD}
vsine vin GND sin({Vcm} 10m 1k)
C1 vout1 GND {Cload} m=1
C2 vout2 GND {Cload} m=1
C3 vout3 GND {Cload} m=1
C4 vout4 GND {Cload} m=1
x1 VDD vin vout4 GND vin vout3 vin vout2 vout1 vin inverter_top
**** begin user architecture code


.include ../../../netlist/pex/inverter_top_magic_pex_3.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.param temp=27
.param Cload=10p
.param Rload=1k
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran 1u 5m
write @schname\.raw

* Plotting
plot vin vout1 vout2 vout3 vout4
plot i(VDD)

* Measurements
meas tran vin_peak MAX v(vin)
meas tran vout_peak MAX v(vout1)

let Adm = vout_peak / vin_peak
let Adm_dB = vdb(Adm)
print Adm_dB

meas tran vout_pp_max MAX v(vout1)
meas tran vout_pp_min MIN v(vout1)
let vout_pp = vout_pp_max - vout_pp_min
print vout_pp

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../../../scripts/plot_simulations/data/@schname\.txt  v(vin) v(vout1) v(vout2) v(vout3)
+ v(vout4)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt

 .include [file rootname [xschem get schname]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
