** sch_path: macros/inverter/verification/cace/templates/inverter_tb_ac.sch
**.subckt inverter_tb_ac
VDD VDD GND CACE{vdd}
C2 vout GND CACE{cload} m=1
VSS VSS GND 0
x1 VDD vin vout GND inverter
vin vin GND dc CACE{vcm} ac 1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.control

* optran 0 0 0 1u 1m 0

* save v(vin) v(vout)
save all

set num_threads=16

* AC Analysis
ac dec 101 1 1G

* Open-loop gain
let Aol=v(vout)/v(vin)
let Aol_dB = vdb(Aol)

* Measurements
* 10Hz closed-loop gain
meas ac Adc_ol_dB find Aol_dB when frequency = 10

* Upper 3dB cut-off frequency
let Amag_fc = Adc_ol_dB-3
meas ac fcu find frequency when Aol_dB = Amag_fc FALL=1

echo $&Adc_ol_dB $&fcu > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerMOShv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_CACE{corner_c}

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
