** sch_path: schematic/xschem/chip_top.sch
**.subckt chip_top clk_PAD rst_n_PAD input_PAD[0] output_PAD[16] analog_PAD[2] analog_PAD[0] IOVDD
*+ VSS VDD VSS bidir_PAD[0] output_PAD[4] output_PAD[5] output_PAD[6] output_PAD[7] output_PAD[8]
*+ output_PAD[9] output_PAD[10] output_PAD[11] analog_PAD[3] analog_PAD[1] output_PAD[12] output_PAD[13]
*+ output_PAD[14] output_PAD[15] output_PAD[3] output_PAD[2] output_PAD[1] output_PAD[0] bidir_PAD[1] bidir_PAD[2]
*+ bidir_PAD[3]
*.ipin clk_PAD
*.ipin rst_n_PAD
*.ipin input_PAD[0]
*.opin output_PAD[16]
*.iopin analog_PAD[2]
*.iopin analog_PAD[0]
*.iopin IOVDD
*.iopin VSS
*.iopin VDD
*.iopin VSS
*.iopin bidir_PAD[0]
*.opin output_PAD[4]
*.opin output_PAD[5]
*.opin output_PAD[6]
*.opin output_PAD[7]
*.opin output_PAD[8]
*.opin output_PAD[9]
*.opin output_PAD[10]
*.opin output_PAD[11]
*.iopin analog_PAD[3]
*.iopin analog_PAD[1]
*.opin output_PAD[12]
*.opin output_PAD[13]
*.opin output_PAD[14]
*.opin output_PAD[15]
*.opin output_PAD[3]
*.opin output_PAD[2]
*.opin output_PAD[1]
*.opin output_PAD[0]
*.iopin bidir_PAD[1]
*.iopin bidir_PAD[2]
*.iopin bidir_PAD[3]
x1 VSS VDD VSS IOVDD net5 clk_PAD sg13g2_IOPadIn
x2 VSS VDD VSS IOVDD net3 rst_n_PAD sg13g2_IOPadIn
x3 VSS VDD VSS IOVDD net4 input_PAD[0] sg13g2_IOPadIn
x4 VSS VDD VSS IOVDD net16 output_PAD[16] sg13g2_IOPadOut30mA
x7 VSS VDD VSS IOVDD sg13g2_IOPadIOVdd
x8 VSS VDD VSS IOVDD sg13g2_IOPadIOVss
x9 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x10 VSS VDD VSS IOVDD sg13g2_IOPadVss
x29 VSS VDD VSS IOVDD analog_PAD[0] net14 sg13g2_IOPadAnalog
x35 VSS VDD VSS IOVDD analog_PAD[2] net1 sg13g2_IOPadAnalog
x11 VSS VDD VSS IOVDD net6 counter1_value4 net4 bidir_PAD[0] sg13g2_IOPadInOut30mA
* noconn analog_PAD[0]
XR1 VSS [expr {$lvs_ignore ? {VSS} : {sub!}}] ptap1 R=262.8 w=0.78e-6 l=0.78e-6
x5 VSS VDD VSS IOVDD counter2_value0 output_PAD[4] sg13g2_IOPadOut30mA
x6 VSS VDD VSS IOVDD counter2_value1 output_PAD[5] sg13g2_IOPadOut30mA
x12 VSS VDD VSS IOVDD counter2_value2 output_PAD[6] sg13g2_IOPadOut30mA
x13 VSS VDD VSS IOVDD counter2_value3 output_PAD[7] sg13g2_IOPadOut30mA
x14 VSS VDD VSS IOVDD counter2_value4 output_PAD[8] sg13g2_IOPadOut30mA
x15 VSS VDD VSS IOVDD counter2_value5 output_PAD[9] sg13g2_IOPadOut30mA
x16 VSS VDD VSS IOVDD counter2_value6 output_PAD[10] sg13g2_IOPadOut30mA
x17 VSS VDD VSS IOVDD counter2_value7 output_PAD[11] sg13g2_IOPadOut30mA
x18 VSS VDD VSS IOVDD analog_PAD[1] net15 sg13g2_IOPadAnalog
x19 VSS VDD VSS IOVDD analog_PAD[3] net2 sg13g2_IOPadAnalog
* noconn analog_PAD[1]
x20 VSS VDD VSS IOVDD net13 output_PAD[12] sg13g2_IOPadOut30mA
x21 VSS VDD VSS IOVDD net12 output_PAD[13] sg13g2_IOPadOut30mA
x22 VSS VDD VSS IOVDD net11 output_PAD[14] sg13g2_IOPadOut30mA
x23 VSS VDD VSS IOVDD net10 output_PAD[15] sg13g2_IOPadOut30mA
x24 VSS VDD VSS IOVDD counter1_value3 output_PAD[3] sg13g2_IOPadOut30mA
x25 VSS VDD VSS IOVDD counter1_value2 output_PAD[2] sg13g2_IOPadOut30mA
x26 VSS VDD VSS IOVDD counter1_value1 output_PAD[1] sg13g2_IOPadOut30mA
x27 VSS VDD VSS IOVDD counter1_value0 output_PAD[0] sg13g2_IOPadOut30mA
x28 VSS VDD VSS IOVDD net7 counter1_value5 net4 bidir_PAD[1] sg13g2_IOPadInOut30mA
x30 VSS VDD VSS IOVDD net8 counter1_value6 net4 bidir_PAD[2] sg13g2_IOPadInOut30mA
x31 VSS VDD VSS IOVDD net9 counter1_value7 net4 bidir_PAD[3] sg13g2_IOPadInOut30mA
* noconn #net1
* noconn #net2
* tap: counter1_value[0..7] --> counter1_value0
* tap: counter1_value[0..7] --> counter1_value1
* tap: counter1_value[0..7] --> counter1_value2
* tap: counter1_value[0..7] --> counter1_value3
* tap: counter1_value[0..7] --> counter1_value4
* tap: counter1_value[0..7] --> counter1_value5
* tap: counter1_value[0..7] --> counter1_value6
* tap: counter1_value[0..7] --> counter1_value7
* tap: counter2_value[0..7] --> counter2_value0
* tap: counter2_value[0..7] --> counter2_value1
* tap: counter2_value[0..7] --> counter2_value2
* tap: counter2_value[0..7] --> counter2_value3
* tap: counter2_value[0..7] --> counter2_value4
* tap: counter2_value[0..7] --> counter2_value5
* tap: counter2_value[0..7] --> counter2_value6
* tap: counter2_value[0..7] --> counter2_value7
R36 net16 VSS 100k m=1
x32 VDD net9 net10 VSS net8 net11 net7 net12 net13 net6 inverter_top
x33 VDD VSS VSS VSS VSS VSS net15 analog_PAD[3] analog_PAD[2] net14 inverter_top
x34 VDD VSS net5 net3 net4 counter1_value0 counter1_value1 counter1_value2 counter1_value3
+ counter1_value4 counter1_value5 counter1_value6 counter1_value7 counter_top
x36 VDD VSS net5 net3 net4 counter2_value0 counter2_value1 counter2_value2 counter2_value3
+ counter2_value4 counter2_value5 counter2_value6 counter2_value7 counter_top
**.ends
.end
