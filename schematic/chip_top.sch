v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 0 0 65 0 {}
L 4 2860 -160 2860 0 {}
L 4 2860 -160 4180 -160 {}
L 4 2860 -80 4180 -80 {}
L 4 3490 -80 3490 0 {}
L 4 3490 -160 3490 -80 {}
L 4 3200 -80 3200 0 {}
L 4 -0 -4460 0 0 {}
L 4 4180 -4460 4180 0 {}
L 4 380 0 4180 0 {}
L 4 -0 -4460 4180 -4460 {}
P 5 38 140 -15 135 -10 125 0 135 10 147.5 22.5 155 30 147.5 30 140 30 135 30 130 25 125 20 115 10 105 20 100 25 95 30 90 30 82.5 30 75 30 82.5 22.5 95 10 105 0 95 -10 82.5 -22.5 75 -30 82.5 -30 90 -30 95 -30 100 -25 105 -20 115 -10 125 -20 130 -25 135 -30 140 -30 147.5 -30 155 -30 147.5 -22.5 140 -15 {fill=true
bezier=1}
T {Chip Top Assembly / Padframe} 1390 -4440 0 0 1.5 1.5 {}
T {2026-03-02 19:23:44} 3500 -60 0 0 0.8 0.8 {}
T {Simon Dorrer} 2870 -140 0 0 0.8 0.8 {}
T {Page 1 of 1} 2870 -60 0 0 0.8 0.8 {}
T {chip_top} 3500 -120 0 0 0.8 0.8 {vcenter=true}
T {Rev. 1} 3210 -60 0 0 0.8 0.8 {}
T {SCHEM} 155 -25 0 0 1 1 {}
T {Note: On-chip decoupling is done by LibreLane Flow!} 40 -200 0 0 1 1 {}
N 510 -3850 510 -690 {lab=IOVDD}
N 510 -3850 3670 -3850 {lab=IOVDD}
N 3670 -3850 3670 -690 {lab=IOVDD}
N 510 -690 3670 -690 {lab=IOVDD}
N 520 -3840 520 -700 {lab=VSS}
N 520 -3840 3660 -3840 {lab=VSS}
N 3660 -3840 3660 -700 {lab=VSS}
N 520 -700 3660 -700 {lab=VSS}
N 530 -3830 530 -710 {lab=VDD}
N 530 -3830 3650 -3830 {lab=VDD}
N 3650 -3830 3650 -710 {lab=VDD}
N 530 -710 3650 -710 {lab=VDD}
N 540 -3820 540 -720 {lab=VSS}
N 3640 -3820 3640 -720 {lab=VSS}
N 540 -720 3640 -720 {lab=VSS}
N 540 -3820 3640 -3820 {lab=VSS}
N 1470 -3810 1470 -3000 {lab=#net1}
N 1680 -3810 1680 -2960 {lab=#net2}
N 1890 -3810 1890 -2920 {lab=#net3}
N 2100 -3810 2100 -2880 {lab=#net4}
N 1660 -1560 1660 -730 {lab=#net5}
N 1870 -1600 1870 -730 {lab=#net6}
N 2080 -1640 2080 -730 {lab=#net7}
N 2290 -1680 2290 -730 {lab=#net8}
N 600 -2160 600 -1440 {lab=#net9}
N 680 -3540 680 -2660 {lab=#net10}
N 660 -3330 660 -2600 {lab=#net11}
N 660 -1940 660 -1020 {lab=#net12}
N 680 -1900 680 -810 {lab=#net13}
N 640 -2080 640 -1230 {lab=#net14}
N 620 -2120 620 -1450 {lab=#net15}
N 620 -2910 620 -2420 {lab=#net16}
N 600 -2700 600 -2380 {lab=#net17}
N 580 -2490 580 -2340 {lab=#net18}
N 1640 -2800 1640 -2780 {lab=VDD}
N 3600 -2370 3630 -2370 {lab=#net19}
N 3880 -910 4000 -910 {lab=analog_PAD[0]}
N 3880 -1120 4000 -1120 {lab=analog_PAD[1]}
N 3880 -1960 4000 -1960 {lab=analog_PAD[2]}
N 3880 -2170 4000 -2170 {lab=analog_PAD[3]}
N 3880 -2380 4000 -2380 {lab=analog_PAD[4]}
N 3880 -2590 4000 -2590 {lab=analog_PAD[5]}
N 3880 -3430 4000 -3430 {lab=analog_PAD[6]}
N 3880 -3640 4000 -3640 {lab=analog_PAD[7]}
N 180 -1320 300 -1320 {lab=output_PAD[5]}
N 180 -900 300 -900 {lab=output_PAD[4]}
N 180 -3000 300 -3000 {lab=output_PAD[8]}
N 180 -2790 300 -2790 {lab=output_PAD[7]}
N 180 -2580 300 -2580 {lab=output_PAD[6]}
N 1570 -480 1570 -360 {lab=output_PAD[0]}
N 1780 -480 1780 -360 {lab=output_PAD[1]}
N 1990 -480 1990 -360 {lab=output_PAD[2]}
N 2200 -480 2200 -360 {lab=output_PAD[3]}
N 2820 -4180 2820 -4060 {lab=bidir_PAD[0]}
N 3030 -4180 3030 -4060 {lab=bidir_PAD[1]}
N 3240 -4180 3240 -4060 {lab=bidir_PAD[2]}
N 3450 -4180 3450 -4060 {lab=bidir_PAD[3]}
N 2830 -480 2830 -360 {lab=bidir_PAD[4]}
N 3040 -480 3040 -360 {lab=bidir_PAD[5]}
N 3250 -480 3250 -360 {lab=bidir_PAD[6]}
N 3460 -480 3460 -360 {lab=bidir_PAD[7]}
N 2610 -3740 2920 -3740 {lab=#net20}
N 2650 -3680 3130 -3680 {lab=#net21}
N 2710 -3620 3340 -3620 {lab=#net22}
N 2750 -3560 3550 -3560 {lab=#net23}
N 2770 -1020 3550 -1020 {lab=#net24}
N 3330 -980 3540 -980 {lab=#net25}
N 3600 -1210 3630 -1210 {lab=#net26}
N 3580 -1000 3630 -1000 {lab=#net27}
N 3580 -3730 3630 -3730 {lab=#net28}
N 3600 -3520 3630 -3520 {lab=#net29}
N 180 -3630 300 -3630 {lab=clk_PAD}
N 180 -3420 300 -3420 {lab=rst_n_PAD}
N 180 -3210 300 -3210 {lab=input_PAD[5]}
N 180 -2370 300 -2370 {lab=IOVDD}
N 180 -2160 300 -2160 {lab=VSS}
N 180 -1950 300 -1950 {lab=VDD}
N 180 -1740 300 -1740 {lab=VSS}
N 180 -1530 300 -1530 {lab=bidir_PAD[8]}
N 180 -1110 300 -1110 {lab=input_PAD[4]}
N 1360 -480 1360 -360 {lab=VSS}
N 1150 -480 1150 -360 {lab=VDD}
N 940 -480 940 -360 {lab=VSS}
N 730 -480 730 -360 {lab=IOVDD}
N 2620 -480 2620 -360 {lab=VSS}
N 2410 -480 2410 -360 {lab=VDD}
N 3880 -1330 4000 -1330 {lab=VSS}
N 3880 -1540 4000 -1540 {lab=VDD}
N 3880 -1750 4000 -1750 {lab=VSS}
N 3880 -2800 4000 -2800 {lab=VSS}
N 3880 -3010 4000 -3010 {lab=VDD}
N 3880 -3220 4000 -3220 {lab=VSS}
N 1350 -4180 1350 -4060 {lab=VSS}
N 1140 -4180 1140 -4060 {lab=VDD}
N 930 -4180 930 -4060 {lab=VSS}
N 720 -4180 720 -4060 {lab=IOVDD}
N 2190 -4180 2190 -4060 {lab=input_PAD[3]}
N 1980 -4180 1980 -4060 {lab=input_PAD[2]}
N 1770 -4180 1770 -4060 {lab=input_PAD[1]}
N 1560 -4180 1560 -4060 {lab=input_PAD[0]}
N 2610 -4180 2610 -4060 {lab=VSS}
N 2400 -4180 2400 -4060 {lab=VDD}
N 2920 -3800 2920 -3740 {lab=#net20}
N 2630 -3720 2730 -3720 {lab=#net30}
N 2590 -3700 2740 -3700 {lab=#net31}
N 2740 -3700 2950 -3700 {lab=#net31}
N 3130 -3800 3130 -3680 {lab=#net21}
N 2670 -3660 2940 -3660 {lab=#net32}
N 2690 -3580 3160 -3580 {lab=#net33}
N 3160 -3580 3370 -3580 {lab=#net33}
N 3550 -3800 3550 -3560 {lab=#net23}
N 2770 -3540 3360 -3540 {lab=#net34}
N 3340 -3800 3340 -3620 {lab=#net22}
N 2730 -3600 3150 -3600 {lab=#net35}
N 2910 -860 2910 -740 {lab=#net36}
N 2910 -860 3120 -860 {lab=#net36}
N 3120 -860 3120 -740 {lab=#net36}
N 2590 -860 2910 -860 {lab=#net36}
N 3330 -980 3330 -740 {lab=#net25}
N 2690 -980 3330 -980 {lab=#net25}
N 3540 -980 3540 -740 {lab=#net25}
N 2610 -820 2730 -820 {lab=#net37}
N 2730 -820 2730 -740 {lab=#net37}
N 2650 -880 2940 -880 {lab=#net38}
N 2940 -880 2940 -740 {lab=#net38}
N 2630 -840 2920 -840 {lab=#net39}
N 2920 -840 2920 -730 {lab=#net39}
N 3130 -900 3130 -730 {lab=#net40}
N 2670 -900 3130 -900 {lab=#net40}
N 3150 -940 3150 -740 {lab=#net41}
N 2710 -940 3150 -940 {lab=#net41}
N 3360 -1000 3360 -740 {lab=#net42}
N 2750 -1000 3360 -1000 {lab=#net42}
N 3340 -960 3340 -730 {lab=#net43}
N 2730 -960 3340 -960 {lab=#net43}
N 3550 -1020 3550 -730 {lab=#net24}
N 580 -2200 580 -1630 {lab=#net44}
N 2730 -3810 2730 -3720 {lab=#net30}
N 2740 -3800 2740 -3700 {lab=#net31}
N 2940 -3810 2940 -3660 {lab=#net32}
N 2950 -3800 2950 -3700 {lab=#net31}
N 3150 -3810 3150 -3600 {lab=#net35}
N 3160 -3800 3160 -3580 {lab=#net33}
N 3360 -3810 3360 -3540 {lab=#net34}
N 3370 -3800 3370 -3580 {lab=#net33}
N 3620 -3630 3630 -3630 {lab=#net45}
N 3620 -3420 3630 -3420 {lab=#net46}
N 3620 -2680 3630 -2680 {lab=#net47}
N 3620 -2470 3630 -2470 {lab=#net48}
N 3620 -2260 3630 -2260 {lab=#net49}
N 3620 -2050 3630 -2050 {lab=#net50}
N 3620 -1110 3630 -1110 {lab=#net51}
N 3620 -900 3630 -900 {lab=#net52}
N 1280 -2880 1280 -2780 {lab=#net4}
N 1220 -2920 1220 -2780 {lab=#net3}
N 1160 -2960 1160 -2780 {lab=#net2}
N 1100 -3000 1100 -2780 {lab=#net1}
N 1640 -1780 1640 -1760 {lab=VSS}
N 1280 -1780 1280 -1680 {lab=#net8}
N 1220 -1780 1220 -1640 {lab=#net7}
N 1160 -1780 1160 -1600 {lab=#net6}
N 1100 -1780 1100 -1560 {lab=#net5}
N 550 -2490 580 -2490 {lab=#net18}
N 550 -2700 600 -2700 {lab=#net17}
N 550 -2910 620 -2910 {lab=#net16}
N 550 -3120 640 -3120 {lab=#net53}
N 640 -3120 640 -2460 {lab=#net53}
N 550 -3330 660 -3330 {lab=#net11}
N 550 -3540 680 -3540 {lab=#net10}
N 560 -1630 580 -1630 {lab=#net44}
N 550 -1440 600 -1440 {lab=#net9}
N 560 -1450 620 -1450 {lab=#net15}
N 550 -1230 640 -1230 {lab=#net14}
N 550 -1020 660 -1020 {lab=#net12}
N 550 -810 680 -810 {lab=#net13}
N 680 -2660 700 -2660 {lab=#net10}
N 660 -2600 700 -2600 {lab=#net11}
N 640 -2460 700 -2460 {lab=#net53}
N 620 -2420 700 -2420 {lab=#net16}
N 600 -2380 700 -2380 {lab=#net17}
N 580 -2340 700 -2340 {lab=#net18}
N 580 -2200 700 -2200 {lab=#net44}
N 600 -2160 700 -2160 {lab=#net9}
N 620 -2120 700 -2120 {lab=#net15}
N 640 -2080 700 -2080 {lab=#net14}
N 660 -1940 700 -1940 {lab=#net12}
N 680 -1900 700 -1900 {lab=#net13}
N 1100 -3000 1470 -3000 {lab=#net1}
N 1160 -2960 1680 -2960 {lab=#net2}
N 1220 -2920 1890 -2920 {lab=#net3}
N 1280 -2880 2100 -2880 {lab=#net4}
N 1100 -1560 1660 -1560 {lab=#net5}
N 1160 -1600 1870 -1600 {lab=#net6}
N 1220 -1640 2080 -1640 {lab=#net7}
N 1280 -1680 2290 -1680 {lab=#net8}
N 3250 -1780 3250 -1760 {lab=VSS}
N 3250 -2800 3250 -2780 {lab=VDD}
N 2580 -2660 2590 -2660 {lab=#net31}
N 2590 -3700 2590 -2660 {lab=#net31}
N 2580 -2620 2610 -2620 {lab=#net20}
N 2610 -3740 2610 -2620 {lab=#net20}
N 2580 -2580 2630 -2580 {lab=#net30}
N 2630 -2620 2630 -2580 {lab=#net30}
N 2580 -2540 2650 -2540 {lab=#net21}
N 2650 -3680 2650 -2540 {lab=#net21}
N 2580 -2500 2670 -2500 {lab=#net32}
N 2580 -2460 2690 -2460 {lab=#net33}
N 2690 -3580 2690 -2460 {lab=#net33}
N 2580 -2420 2710 -2420 {lab=#net22}
N 2710 -3620 2710 -2420 {lab=#net22}
N 2580 -2380 2730 -2380 {lab=#net35}
N 2730 -3600 2730 -2380 {lab=#net35}
N 2580 -2340 2750 -2340 {lab=#net23}
N 2750 -3560 2750 -2340 {lab=#net23}
N 2580 -2300 2770 -2300 {lab=#net34}
N 2770 -3540 2770 -2300 {lab=#net34}
N 2580 -1900 2590 -1900 {lab=#net36}
N 2590 -1900 2590 -860 {lab=#net36}
N 2580 -1940 2610 -1940 {lab=#net37}
N 2610 -1940 2610 -820 {lab=#net37}
N 2580 -1980 2630 -1980 {lab=#net39}
N 2580 -2020 2650 -2020 {lab=#net38}
N 2650 -2020 2650 -880 {lab=#net38}
N 2580 -2060 2670 -2060 {lab=#net40}
N 2580 -2100 2690 -2100 {lab=#net25}
N 2690 -2100 2690 -980 {lab=#net25}
N 2580 -2140 2710 -2140 {lab=#net41}
N 2710 -2140 2710 -940 {lab=#net41}
N 2580 -2180 2730 -2180 {lab=#net43}
N 2730 -2180 2730 -960 {lab=#net43}
N 2580 -2220 2750 -2220 {lab=#net42}
N 2750 -2220 2750 -1000 {lab=#net42}
N 2580 -2260 2770 -2260 {lab=#net24}
N 2770 -2260 2770 -1020 {lab=#net24}
N 2580 -2700 2910 -2700 {lab=#net54}
N 3580 -3730 3580 -3420 {lab=#net28}
N 2630 -3720 2630 -2620 {lab=#net30}
N 2670 -3660 2670 -2500 {lab=#net32}
N 2580 -1860 2910 -1860 {lab=#net55}
N 2630 -1940 2630 -840 {lab=#net39}
N 2670 -2060 2670 -900 {lab=#net40}
N 2770 -2300 2910 -2300 {lab=#net34}
N 3590 -2600 3610 -2600 {lab=#net56}
N 3610 -2600 3610 -2580 {lab=#net56}
N 3610 -2580 3630 -2580 {lab=#net56}
N 3590 -2540 3600 -2540 {lab=#net19}
N 3600 -2540 3600 -2370 {lab=#net19}
N 3590 -1960 3610 -1960 {lab=#net57}
N 3610 -1960 3610 -1950 {lab=#net57}
N 3610 -1950 3630 -1950 {lab=#net57}
N 3600 -2160 3630 -2160 {lab=#net58}
N 3600 -2160 3600 -2020 {lab=#net58}
N 3590 -2020 3600 -2020 {lab=#net58}
N 2770 -2260 2910 -2260 {lab=#net24}
N 2730 -2180 2910 -2180 {lab=#net43}
N 2730 -2380 2910 -2380 {lab=#net35}
N 2670 -2480 2910 -2480 {lab=#net32}
N 2670 -2500 2670 -2480 {lab=#net32}
N 2630 -2620 2910 -2620 {lab=#net30}
N 2790 -3420 3580 -3420 {lab=#net28}
N 2790 -3420 2790 -2660 {lab=#net28}
N 2790 -2660 2910 -2660 {lab=#net28}
N 2810 -3400 3600 -3400 {lab=#net29}
N 3600 -3520 3600 -3400 {lab=#net29}
N 2810 -3400 2810 -2520 {lab=#net29}
N 2810 -2520 2910 -2520 {lab=#net29}
N 2790 -1900 2910 -1900 {lab=#net27}
N 3580 -1310 3580 -1000 {lab=#net27}
N 2790 -1310 3580 -1310 {lab=#net27}
N 2790 -1900 2790 -1310 {lab=#net27}
N 3600 -1330 3600 -1210 {lab=#net26}
N 2810 -1330 3600 -1330 {lab=#net26}
N 2810 -2040 2810 -1330 {lab=#net26}
N 2810 -2040 2910 -2040 {lab=#net26}
N 2630 -1940 2910 -1940 {lab=#net39}
N 2630 -1980 2630 -1940 {lab=#net39}
N 2670 -2080 2910 -2080 {lab=#net40}
N 2670 -2080 2670 -2060 {lab=#net40}
N 2500 -2800 2500 -2780 {lab=#net59}
N 2500 -2800 2990 -2800 {lab=#net59}
N 2990 -2800 2990 -2780 {lab=#net59}
N 3840 -420 3840 -400 {lab=VSS}
N 3840 -500 3840 -480 {lab=sub!}
C {sg13g2_io/sg13g2_IOPadIn.sym} 200 -3740 1 0 {name=x1}
C {sg13g2_io/sg13g2_IOPadIn.sym} 200 -3530 1 0 {name=x2}
C {sg13g2_io/sg13g2_IOPadIn.sym} 200 -3320 1 0 {name=x3}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 200 -3110 1 0 {name=x4}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 200 -2900 1 0 {name=x5}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 200 -2690 1 0 {name=x6}
C {sg13g2_io/sg13g2_IOPadIOVdd.sym} 200 -2480 1 0 {name=x7}
C {sg13g2_io/sg13g2_IOPadIOVss.sym} 200 -2270 1 0 {name=x8}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 200 -2060 1 0 {name=x9}
C {sg13g2_io/sg13g2_IOPadVss.sym} 200 -1850 1 0 {name=x10}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 200 -1430 1 0 {name=x12}
C {sg13g2_io/sg13g2_IOPadIn.sym} 200 -1220 1 0 {name=x13}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 200 -1010 1 0 {name=x14}
C {sg13g2_io/sg13g2_IOPadIOVdd.sym} 620 -380 0 0 {name=x15}
C {sg13g2_io/sg13g2_IOPadIOVss.sym} 830 -380 0 0 {name=x16}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 1040 -380 0 0 {name=x17}
C {sg13g2_io/sg13g2_IOPadVss.sym} 1250 -380 0 0 {name=x18}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 1460 -380 0 0 {name=x19}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 1670 -380 0 0 {name=x20}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 1880 -380 0 0 {name=x21}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 2090 -380 0 0 {name=x22}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 2300 -380 0 0 {name=x23}
C {sg13g2_io/sg13g2_IOPadVss.sym} 2510 -380 0 0 {name=x24}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -800 3 0 {name=x29}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -1010 3 0 {name=x30}
C {sg13g2_io/sg13g2_IOPadVss.sym} 3980 -1220 3 0 {name=x31}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 3980 -1430 3 0 {name=x32}
C {sg13g2_io/sg13g2_IOPadVss.sym} 3980 -1640 3 0 {name=x33}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -2060 3 0 {name=x35}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -2270 3 0 {name=x36}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -2480 3 0 {name=x37}
C {sg13g2_io/sg13g2_IOPadVss.sym} 3980 -2690 3 0 {name=x38}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 3980 -2900 3 0 {name=x39}
C {sg13g2_io/sg13g2_IOPadVss.sym} 3980 -3110 3 0 {name=x40}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 2510 -4160 2 0 {name=x48}
C {sg13g2_io/sg13g2_IOPadVss.sym} 2720 -4160 2 0 {name=x47}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -3320 3 0 {name=x41}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -3530 3 0 {name=x42}
C {sg13g2_io/sg13g2_IOPadIn.sym} 2300 -4160 2 0 {name=x49}
C {sg13g2_io/sg13g2_IOPadIn.sym} 2090 -4160 2 0 {name=x50}
C {sg13g2_io/sg13g2_IOPadIn.sym} 1880 -4160 2 0 {name=x51}
C {sg13g2_io/sg13g2_IOPadIn.sym} 1670 -4160 2 0 {name=x52}
C {sg13g2_io/sg13g2_IOPadIOVdd.sym} 830 -4160 2 0 {name=x56}
C {sg13g2_io/sg13g2_IOPadIOVss.sym} 1040 -4160 2 0 {name=x55}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 1250 -4160 2 0 {name=x54}
C {sg13g2_io/sg13g2_IOPadVss.sym} 1460 -4160 2 0 {name=x53}
C {devices/iopin.sym} 720 -4180 1 1 {name=p8 lab=IOVDD}
C {devices/iopin.sym} 930 -4180 1 1 {name=p9 lab=VSS}
C {devices/iopin.sym} 1140 -4180 1 1 {name=p10 lab=VDD}
C {devices/iopin.sym} 1350 -4180 1 1 {name=p11 lab=VSS}
C {devices/iopin.sym} 2410 -360 1 0 {name=p16 lab=VDD}
C {devices/iopin.sym} 2620 -360 1 0 {name=p17 lab=VSS}
C {devices/iopin.sym} 4000 -1540 0 0 {name=p23 lab=VDD}
C {devices/iopin.sym} 4000 -1750 0 0 {name=p24 lab=VSS}
C {devices/iopin.sym} 4000 -1330 0 0 {name=p25 lab=VSS}
C {devices/ipin.sym} 180 -3630 2 1 {name=p1 lab=clk_PAD}
C {devices/ipin.sym} 180 -3420 0 0 {name=p2 lab=rst_n_PAD}
C {devices/ipin.sym} 180 -3210 2 1 {name=p3 lab=input_PAD[5]}
C {devices/ipin.sym} 180 -1110 0 0 {name=p27 lab=input_PAD[4]
}
C {devices/opin.sym} 180 -900 0 1 {name=p28 lab=output_PAD[4]
}
C {devices/opin.sym} 180 -3000 2 0 {name=p29 lab=output_PAD[8]
}
C {devices/opin.sym} 180 -2790 2 0 {name=p30 lab=output_PAD[7]
}
C {devices/opin.sym} 180 -2580 2 0 {name=p31 lab=output_PAD[6]
}
C {devices/opin.sym} 180 -1320 2 0 {name=p34 lab=output_PAD[5]
}
C {devices/ipin.sym} 2190 -4180 1 0 {name=p35 lab=input_PAD[3]
}
C {devices/ipin.sym} 1980 -4180 1 0 {name=p36 lab=input_PAD[2]
}
C {devices/ipin.sym} 1770 -4180 1 0 {name=p37 lab=input_PAD[1]
}
C {devices/ipin.sym} 1560 -4180 1 0 {name=p38 lab=input_PAD[0]
}
C {devices/opin.sym} 2200 -360 1 0 {name=p39 lab=output_PAD[3]
}
C {devices/opin.sym} 1990 -360 1 0 {name=p40 lab=output_PAD[2]
}
C {devices/opin.sym} 1780 -360 1 0 {name=p41 lab=output_PAD[1]
}
C {devices/opin.sym} 1570 -360 1 0 {name=p42 lab=output_PAD[0]
}
C {devices/iopin.sym} 4000 -2590 0 0 {name=p43 lab=analog_PAD[5]}
C {devices/iopin.sym} 4000 -2380 0 0 {name=p44 lab=analog_PAD[4]}
C {devices/iopin.sym} 4000 -1960 0 0 {name=p45 lab=analog_PAD[2]}
C {devices/iopin.sym} 4000 -2170 0 0 {name=p46 lab=analog_PAD[3]}
C {devices/iopin.sym} 4000 -3640 0 0 {name=p57 lab=analog_PAD[7]}
C {devices/iopin.sym} 4000 -3430 0 0 {name=p58 lab=analog_PAD[6]}
C {devices/iopin.sym} 4000 -910 0 0 {name=p59 lab=analog_PAD[0]}
C {devices/iopin.sym} 4000 -1120 0 0 {name=p60 lab=analog_PAD[1]}
C {lab_pin.sym} 1640 -1760 3 0 {name=p52 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1640 -2800 1 0 {name=p53 sig_type=std_logic lab=VDD}
C {devices/iopin.sym} 4000 -3010 0 0 {name=p78 lab=VDD}
C {devices/iopin.sym} 4000 -3220 0 0 {name=p79 lab=VSS}
C {devices/iopin.sym} 4000 -2800 0 0 {name=p80 lab=VSS}
C {devices/iopin.sym} 180 -2370 2 0 {name=p20 lab=IOVDD}
C {devices/iopin.sym} 180 -2160 2 0 {name=p21 lab=VSS}
C {devices/iopin.sym} 180 -1950 2 0 {name=p22 lab=VDD}
C {devices/iopin.sym} 180 -1740 2 0 {name=p81 lab=VSS}
C {devices/iopin.sym} 730 -360 1 0 {name=p4 lab=IOVDD}
C {devices/iopin.sym} 940 -360 1 0 {name=p5 lab=VSS}
C {devices/iopin.sym} 1150 -360 1 0 {name=p6 lab=VDD}
C {devices/iopin.sym} 1360 -360 1 0 {name=p7 lab=VSS}
C {devices/iopin.sym} 180 -1530 2 0 {name=p12 lab=bidir_PAD[8]
}
C {devices/iopin.sym} 2400 -4180 1 1 {name=p13 lab=VDD}
C {devices/iopin.sym} 2610 -4180 1 1 {name=p14 lab=VSS}
C {devices/iopin.sym} 2830 -360 1 0 {name=p15 lab=bidir_PAD[4]
}
C {devices/iopin.sym} 3040 -360 1 0 {name=p18 lab=bidir_PAD[5]
}
C {devices/iopin.sym} 3460 -360 1 0 {name=p19 lab=bidir_PAD[7]
}
C {devices/iopin.sym} 3250 -360 1 0 {name=p82 lab=bidir_PAD[6]
}
C {devices/iopin.sym} 2820 -4180 3 0 {name=p83 lab=bidir_PAD[0]
}
C {devices/iopin.sym} 3030 -4180 3 0 {name=p84 lab=bidir_PAD[1]
}
C {devices/iopin.sym} 3450 -4180 3 0 {name=p85 lab=bidir_PAD[3]
}
C {devices/iopin.sym} 3240 -4180 3 0 {name=p86 lab=bidir_PAD[2]
}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 200 -1640 1 0 {name=x11}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 2720 -380 0 0 {name=x25}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 2930 -380 0 0 {name=x26}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 3140 -380 0 0 {name=x27}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 3350 -380 0 0 {name=x28}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 3560 -4160 2 0 {name=x43}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 3350 -4160 2 0 {name=x44}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 3140 -4160 2 0 {name=x45}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 2930 -4160 2 0 {name=x46}
C {sg13g2_io/sg13g2_IOPadAnalog.sym} 3980 -1850 3 0 {name=x34}
C {noconn.sym} 3620 -3630 0 0 {name=l1}
C {noconn.sym} 3620 -3420 0 0 {name=l2}
C {noconn.sym} 3620 -2680 0 0 {name=l3}
C {noconn.sym} 3620 -2470 0 0 {name=l4}
C {noconn.sym} 3620 -2260 0 0 {name=l5}
C {noconn.sym} 3620 -2050 0 0 {name=l6}
C {noconn.sym} 3620 -1110 0 0 {name=l7}
C {noconn.sym} 3620 -900 0 0 {name=l8}
C {ngspice_probe.sym} 510 -3850 0 0 {name=r2}
C {ngspice_probe.sym} 520 -3840 0 0 {name=r3}
C {ngspice_probe.sym} 530 -3830 0 0 {name=r4}
C {ngspice_probe.sym} 540 -3820 0 0 {name=r5}
C {ngspice_probe.sym} 1640 -1760 0 0 {name=r6}
C {ngspice_probe.sym} 1640 -2780 0 0 {name=r7}
C {ngspice_probe.sym} 550 -3540 0 0 {name=r13}
C {ngspice_probe.sym} 550 -3330 0 0 {name=r14}
C {ngspice_probe.sym} 550 -3120 0 0 {name=r15}
C {ngspice_probe.sym} 550 -2910 0 0 {name=r16}
C {ngspice_probe.sym} 550 -2700 0 0 {name=r17}
C {ngspice_probe.sym} 550 -2490 0 0 {name=r18}
C {ngspice_probe.sym} 560 -1630 0 0 {name=r19}
C {ngspice_probe.sym} 560 -1450 0 0 {name=r20}
C {ngspice_probe.sym} 550 -1440 0 0 {name=r21}
C {ngspice_probe.sym} 550 -1230 0 0 {name=r22}
C {ngspice_probe.sym} 550 -1020 0 0 {name=r23}
C {ngspice_probe.sym} 550 -810 0 0 {name=r24}
C {ngspice_probe.sym} 1470 -3810 0 0 {name=r9}
C {ngspice_probe.sym} 1680 -3810 0 0 {name=r10}
C {ngspice_probe.sym} 1890 -3810 0 0 {name=r11}
C {ngspice_probe.sym} 2100 -3810 0 0 {name=r12}
C {ngspice_probe.sym} 2730 -3810 0 0 {name=r25}
C {ngspice_probe.sym} 2740 -3800 0 0 {name=r26}
C {ngspice_probe.sym} 2920 -3800 0 0 {name=r27}
C {ngspice_probe.sym} 2940 -3810 0 0 {name=r28}
C {ngspice_probe.sym} 2950 -3800 0 0 {name=r29}
C {ngspice_probe.sym} 3130 -3800 0 0 {name=r30}
C {ngspice_probe.sym} 3150 -3810 0 0 {name=r31}
C {ngspice_probe.sym} 3160 -3800 0 0 {name=r32}
C {ngspice_probe.sym} 3340 -3800 0 0 {name=r33}
C {ngspice_probe.sym} 3360 -3810 0 0 {name=r34}
C {ngspice_probe.sym} 3370 -3800 0 0 {name=r35}
C {ngspice_probe.sym} 3550 -3800 0 0 {name=r36}
C {ngspice_probe.sym} 3630 -3730 0 0 {name=r37}
C {ngspice_probe.sym} 3630 -3520 0 0 {name=r38}
C {ngspice_probe.sym} 3630 -2580 0 0 {name=r39}
C {ngspice_probe.sym} 3630 -2370 0 0 {name=r40}
C {ngspice_probe.sym} 3630 -2160 0 0 {name=r41}
C {ngspice_probe.sym} 3630 -1950 0 0 {name=r42}
C {ngspice_probe.sym} 3630 -1210 0 0 {name=r43}
C {ngspice_probe.sym} 3630 -1000 0 0 {name=r44}
C {ngspice_probe.sym} 3550 -730 0 0 {name=r45}
C {ngspice_probe.sym} 3540 -740 0 0 {name=r46}
C {ngspice_probe.sym} 3360 -740 0 0 {name=r47}
C {ngspice_probe.sym} 3340 -730 0 0 {name=r48}
C {ngspice_probe.sym} 3330 -740 0 0 {name=r49}
C {ngspice_probe.sym} 3150 -740 0 0 {name=r50}
C {ngspice_probe.sym} 3130 -730 0 0 {name=r51}
C {ngspice_probe.sym} 3120 -740 0 0 {name=r52}
C {ngspice_probe.sym} 2940 -740 0 0 {name=r53}
C {ngspice_probe.sym} 2920 -730 0 0 {name=r54}
C {ngspice_probe.sym} 2910 -740 0 0 {name=r55}
C {ngspice_probe.sym} 2730 -740 0 0 {name=r56}
C {ngspice_probe.sym} 2290 -730 0 0 {name=r57}
C {ngspice_probe.sym} 2080 -730 0 0 {name=r58}
C {ngspice_probe.sym} 1870 -730 0 0 {name=r59}
C {ngspice_probe.sym} 1660 -730 0 0 {name=r60}
C {riscv_top.sym} 1640 -2280 0 0 {name=xcpu}
C {lab_pin.sym} 3250 -1760 3 0 {name=p26 sig_type=std_logic lab=VSS}
C {iqmod_top.sym} 3250 -2280 0 0 {name=xiqmod
lvs_ignore=true}
C {lab_pin.sym} 3250 -2800 1 0 {name=p33 sig_type=std_logic lab=VDD}
C {ngspice_probe.sym} 3250 -2780 0 0 {name=r62}
C {sg13g2_pr/ptap1.sym} 3840 -450 2 1 {name=R1
model=ptap1
spiceprefix=X
w=0.78e-6
l=0.78e-6
lvs_ignore=short}
C {lab_pin.sym} 3840 -400 3 0 {name=p32 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3840 -500 0 0 {name=p47 sig_type=std_logic lab="tcleval([expr \{$lvs_ignore ? \{VSS\} : \{sub!\}\}])"}
